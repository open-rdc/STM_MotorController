# Keil uVision project STM_MotorController.uvproj, settings and files
target STM_MotorController (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM_MotorController
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1
  c define: TARGET_FF_ARDUINO, TARGET_NUCLEO_F103RB, TARGET_FF_MORPHO, TARGET_LIKE_CORTEX_M3, TARGET_CORTEX_M, TOOLCHAIN_ARM_MICRO, TARGET_STM32F1, __MBED__=1, ARM_MATH_CM3, MBED_BUILD_TIMESTAMP=1463274975, TARGET_STM, __CORTEX_M3, TARGET_M3, TOOLCHAIN_ARM, TARGET_STM32F103RB, TARGET_LIKE_MBED, __ASSERT_MSG
  c misc: --gnu --no_rtti --restrict --apcs=interwork -c -O3 -I"C:/Program Files/ARM/armcc_4.1_791/include" --split_sections --multibyte_chars --brief_diagnostics --library_type=microlib -D__ASSERT_MSG --no_depend_system_headers --md --cpu=Cortex-M3 -Otime --gnu --brief_diagnostics --library_type=microlib --cpu=Cortex-M3 --apcs=interwork
  c include: .;L152RE_USBDevice;L152RE_USBDevice/USBDevice;L152RE_USBDevice/USBSerial;STM32_USB48MHz;mbed;mbed/TARGET_NUCLEO_F103RB;mbed/TARGET_NUCLEO_F103RB/TARGET_STM;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO
  asm define: as above
  asm misc: --brief_diagnostics -I"C:/Program Files/ARM/armcc_4.1_791/include" --cpu=Cortex-M3 --apcs=interwork
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/stm32f103xb.sct
  link misc: --library_type=microlib
  group Include Files
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F103RB/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f103xb.h stm32f1xx.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.h system_stm32f1xx.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/: gpio_object.h PeripheralPins.h
    ./: Watchdog.h AS5600.h RS485.h STM_BLDCMotor.h
    ./STM32_USB48MHz/: STM32_USB48MHz.h
    ./L152RE_USBDevice/USBSerial/: CircBuffer.h USBCDC.h USBSerial.h
    ./L152RE_USBDevice/USBDevice/: USBEndpoints.h USBEndpoints_KL25Z.h USBEndpoints_LPC11U.h USBEndpoints_LPC17_LPC23.h USBEndpoints_Maxim.h USBEndpoints_RZ_A1H.h USBEndpoints_STM32F4.h USBEndpoints_STM32L1.h
  group Source Files
    ./STM32_USB48MHz/: STM32_USB48MHz.cpp
    mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f103xb.o stm32f1xx_hal.o stm32f1xx_hal_adc.o stm32f1xx_hal_adc_ex.o stm32f1xx_hal_can.o stm32f1xx_hal_cec.o stm32f1xx_hal_cortex.o stm32f1xx_hal_crc.o stm32f1xx_hal_dac.o stm32f1xx_hal_dac_ex.o stm32f1xx_hal_dma.o stm32f1xx_hal_eth.o stm32f1xx_hal_flash.o stm32f1xx_hal_flash_ex.o stm32f1xx_hal_gpio.o stm32f1xx_hal_gpio_ex.o stm32f1xx_hal_hcd.o stm32f1xx_hal_i2c.o stm32f1xx_hal_i2s.o stm32f1xx_hal_irda.o stm32f1xx_hal_iwdg.o stm32f1xx_hal_nand.o stm32f1xx_hal_nor.o stm32f1xx_hal_pccard.o stm32f1xx_hal_pcd.o stm32f1xx_hal_pcd_ex.o stm32f1xx_hal_pwr.o stm32f1xx_hal_rcc.o stm32f1xx_hal_rcc_ex.o stm32f1xx_hal_rtc.o stm32f1xx_hal_rtc_ex.o stm32f1xx_hal_sd.o stm32f1xx_hal_smartcard.o stm32f1xx_hal_spi.o stm32f1xx_hal_spi_ex.o stm32f1xx_hal_sram.o stm32f1xx_hal_tim.o stm32f1xx_hal_tim_ex.o stm32f1xx_hal_uart.o stm32f1xx_hal_usart.o stm32f1xx_hal_wwdg.o stm32f1xx_ll_fsmc.o stm32f1xx_ll_sdmmc.o stm32f1xx_ll_usb.o sys.o
    ./: main.cpp
    ./: AS5600.cpp RS485.cpp STM_BLDCMotor.cpp system_stm32f1xx.c
    ./L152RE_USBDevice/USBSerial/: USBCDC.cpp USBSerial.cpp
    ./L152RE_USBDevice/USBDevice/: USBDevice.cpp USBHAL_STM32L1.cpp
